options:
  parameters:
    generate_options: hb
    id: msk_mod
    output_language: python
    title: MSK Modulator
  states: {}

blocks:
- name: samp_per_symb
  id: variable
  parameters:
    value: samp_rate/symb_rate
  states: {}
- name: symb_period
  id: variable
  parameters:
    value: 1/symb_rate
  states: {}
- name: A
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/A
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/A
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: s(t)
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    norm_window: 'True'
    type: float
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    norm_window: 'True'
    type: float
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color1: dark blue
    color4: cyan
    ctrlpanel: 'True'
    label1: Q
    label2: COS Symbol Rate
    label3: Q*cos
    label4: Q*cos*cos
    name: Q*cos*cos
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    color4: cyan
    ctrlpanel: 'True'
    label1: I
    label2: SIN symbol rate
    label3: Q*sin
    label4: Q*sin*sin
    name: I*sin*sin
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: s(t)
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: Carrier
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: random_bits_0
  id: random_bits
  parameters:
    samples_per_symbol: samp_per_symb
    symb_rate: symb_rate
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    type: intx
    value: '512000'
  states: {}
- name: sin_cos_gen_0
  id: sin_cos_gen
  parameters:
    A: A
    Fc: symb_rate/2
    Fs: samp_rate
  states: {}
- name: sin_cos_gen_0_0
  id: sin_cos_gen
  parameters:
    A: A
    Fc: samp_rate/51
    Fs: samp_rate
  states: {}
- name: symb_rate
  id: parameter
  parameters:
    type: intx
    value: '4000'
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_1, '1']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_multiply_const_vxx_1_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0_1_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_multiply_xx_0_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_multiply_xx_0_1_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_multiply_xx_1, '0', pad_sink_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [random_bits_0, '0', blocks_multiply_xx_0_0, '0']
- [random_bits_0, '0', qtgui_time_sink_x_0, '0']
- [random_bits_0, '1', blocks_multiply_xx_0, '0']
- [random_bits_0, '1', qtgui_time_sink_x_0_0, '0']
- [sin_cos_gen_0, '0', blocks_multiply_xx_0, '1']
- [sin_cos_gen_0, '0', qtgui_time_sink_x_0_0, '1']
- [sin_cos_gen_0, '1', blocks_multiply_xx_0_0, '1']
- [sin_cos_gen_0, '1', qtgui_time_sink_x_0, '1']
- [sin_cos_gen_0_0, '0', blocks_multiply_xx_0_1, '1']
- [sin_cos_gen_0_0, '0', qtgui_time_sink_x_2, '1']
- [sin_cos_gen_0_0, '1', blocks_multiply_xx_0_1_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
