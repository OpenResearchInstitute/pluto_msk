options:
  parameters:
    generate_options: hb
    id: sin_cos_gen
    output_language: python
    title: Sin/Cos Generator
  states: {}

blocks:
- name: A
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: Fc
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: Fs
  id: parameter
  parameters:
    type: eng_float
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: A
    freq: Fc
    offset: '0'
    phase: '0'
    samp_rate: Fs
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: SIN
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: COS
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_0, '0']
- [blocks_complex_to_float_0, '0', pad_sink_2, '0']
- [blocks_complex_to_float_0, '1', pad_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
